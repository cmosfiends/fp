* # FILE NAME: /NFS/STAK/STUDENTS/L/LOVETR/CADENCE/SIMULATION/
* FINAL_SCHEM_FC_CUBED_LESS/HSPICES/SCHEMATIC/NETLIST/
* FINAL_SCHEM_FC_CUBED_LESS.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON MAR 10 22:26:33 2016

* GLOBAL NET DEFINITIONS
.GLOBAL VCM_REF! VDD!
* FILE NAME: FINAL_PROJECT_FINAL_SCHEM_FC_CUBED_LESS_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_SCHEM_FC_CUBED_LESS.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 10 22:26:33 2016.

R0 NET0144 NET0123  25E3 M=1.0
R1 NET0123 NET0148  25E3 M=1.0
C2 NET0144 NET0123  1E-12 M=1.0
C3 NET0123 NET0148  1E-12 M=1.0
I0 NET0348 0  DC=5E-6  M=1.0
V2 VINN 0  1.25 AC 500E-3 180.0
V3 VCM_REF! 0  1.25
V0 VDD! 0  2.5
V1 VINP 0  1.25 AC 500E-3
MP31 0 VOUTP NET0144 VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP34 0 VOUTN NET0148 VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP35 NET0148 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP36 B B VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12 AS=25.92E-12
+PD=87.6E-6 PS=87.6E-6 M=1
MP37 NET0205 NET0205 VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP32 NET0211 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP33 0 VCM_REF! NET0211 VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP44 NET0347 PB2 NET0214 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP38 NET0262 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=286.8E-6 AD=172.08E-12
+AS=172.08E-12 PD=574.8E-6 PS=574.8E-6 M=1
MP42 NET0278 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP43 NET0214 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP48 NET0229 NET0229 PB2 VDD!  TSMC25DP  L=240E-9 W=2.88E-6 AD=1.728E-12
+AS=1.728E-12 PD=6.96E-6 PS=6.96E-6 M=1
MP51 NET0250 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=286.8E-6 AD=172.08E-12
+AS=172.08E-12 PD=574.8E-6 PS=574.8E-6 M=1
MP41 NET0235 NET212 NET0262 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP46 PB1 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=2.88E-6 AD=1.728E-12 AS=1.728E-12
+PD=6.96E-6 PS=6.96E-6 M=1
MP49 NET202 PB2 NET0363 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP56 NET0359 PB2 NET0250 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP52 NET0363 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=286.8E-6 AD=172.08E-12
+AS=172.08E-12 PD=574.8E-6 PS=574.8E-6 M=1
MP47 PB2 NET0229 PB1 VDD!  TSMC25DP  L=720E-9 W=2.88E-6 AD=1.728E-12
+AS=1.728E-12 PD=6.96E-6 PS=6.96E-6 M=1
MP18 NET0232 NET0348 VDD! VDD!  TSMC25DP  L=240E-9 W=2.88E-6 AD=1.728E-12
+AS=1.728E-12 PD=6.96E-6 PS=6.96E-6 M=1
MP30 NET0144 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP40 NET0351 NET226 NET0262 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP45 NET0339 PB2 NET0278 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP17 NET0348 NET0348 VDD! VDD!  TSMC25DP  L=240E-9 W=2.88E-6 AD=1.728E-12
+AS=1.728E-12 PD=6.96E-6 PS=6.96E-6 M=1
MP5 VOUTN NET202 NET0365 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP4 VOUTP NET0359 NET0393 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP3 NET0365 B VDD! VDD!  TSMC25DP  L=960E-9 W=286.8E-6 AD=172.08E-12
+AS=172.08E-12 PD=574.8E-6 PS=574.8E-6 M=1
MP2 NET0393 B VDD! VDD!  TSMC25DP  L=960E-9 W=286.8E-6 AD=172.08E-12
+AS=172.08E-12 PD=574.8E-6 PS=574.8E-6 M=1
MN33 NET0205 NET0123 NET0208 0  TSMC25DN  L=240E-9 W=14.4E-6 AD=8.64E-12
+AS=8.64E-12 PD=30E-6 PS=30E-6 M=1
MN34 B NET0211 NET0208 0  TSMC25DN  L=240E-9 W=14.4E-6 AD=8.64E-12 AS=8.64E-12
+PD=30E-6 PS=30E-6 M=1
MN39 NET0261 NB1 0 0  TSMC25DN  L=240E-9 W=28.8E-6 AD=17.28E-12 AS=17.28E-12
+PD=58.8E-6 PS=58.8E-6 M=1
MN40 NET0208 NB2 NET0261 0  TSMC25DN  L=240E-9 W=28.8E-6 AD=17.28E-12
+AS=17.28E-12 PD=58.8E-6 PS=58.8E-6 M=1
MN46 NET0229 NB1 0 0  TSMC25DN  L=240E-9 W=960E-9 AD=576E-15 AS=576E-15
+PD=3.12E-6 PS=3.12E-6 M=1
MN26 NB2 NET0232 NB1 0  TSMC25DN  L=720E-9 W=960E-9 AD=576E-15 AS=576E-15
+PD=3.12E-6 PS=3.12E-6 M=1
MN41 NET0339 NB2 NET0351 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN22 NB1 NB1 0 0  TSMC25DN  L=240E-9 W=960E-9 AD=576E-15 AS=576E-15 PD=3.12E-6
+PS=3.12E-6 M=1
MN42 NET0347 NB2 NET0235 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN43 NET0351 NB1 0 0  TSMC25DN  L=240E-9 W=99.96E-6 AD=59.976E-12
+AS=59.976E-12 PD=201.12E-6 PS=201.12E-6 M=1
MN53 NET0406 NB1 0 0  TSMC25DN  L=240E-9 W=99.96E-6 AD=59.976E-12
+AS=59.976E-12 PD=201.12E-6 PS=201.12E-6 M=1
MN48 NET0359 NB2 NET0371 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN54 NET0363 NET0365 NET0406 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN49 NET202 NB2 NET0375 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN50 NET0371 NB1 0 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN51 NET0375 NB1 0 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN23 NET0232 NET0232 NB2 0  TSMC25DN  L=240E-9 W=960E-9 AD=576E-15 AS=576E-15
+PD=3.12E-6 PS=3.12E-6 M=1
MN15 NET241 NB2 NET0173 0  TSMC25DN  L=240E-9 W=99.96E-6 AD=59.976E-12
+AS=59.976E-12 PD=201.12E-6 PS=201.12E-6 M=1
MN55 NET0250 NET0393 NET0406 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN44 NET0235 NB1 0 0  TSMC25DN  L=240E-9 W=99.96E-6 AD=59.976E-12
+AS=59.976E-12 PD=201.12E-6 PS=201.12E-6 M=1
MN6 VOUTN NET0347 NET212 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN5 VOUTP NET0339 NET226 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN4 NET212 NB1 0 0  TSMC25DN  L=960E-9 W=49.98E-6 AD=29.988E-12 AS=29.988E-12
+PD=101.16E-6 PS=101.16E-6 M=1
MN3 NET226 NB1 0 0  TSMC25DN  L=960E-9 W=49.98E-6 AD=29.988E-12 AS=29.988E-12
+PD=101.16E-6 PS=101.16E-6 M=1
MN2 NET0173 NB1 0 0  TSMC25DN  L=240E-9 W=99.96E-6 AD=59.976E-12 AS=59.976E-12
+PD=201.12E-6 PS=201.12E-6 M=1
MN1 NET0393 VINN NET241 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1
MN0 NET0365 VINP NET241 0  TSMC25DN  L=240E-9 W=49.98E-6 AD=29.988E-12
+AS=29.988E-12 PD=101.16E-6 PS=101.16E-6 M=1

.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dN" NMOS
.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dP" PMOS

* INCLUDE FILES

* END OF NETLIST
.TEMP    25.0000
.OP
.save
.OPTION POST
.END
