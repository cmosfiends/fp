* # FILE NAME: /NFS/STAK/STUDENTS/L/LOVETR/CADENCE/SIMULATION/
* FINAL_SCHEM_SOOCH_NCMF_ANAL/HSPICES/SCHEMATIC/NETLIST/
* FINAL_SCHEM_SOOCH_NCMF_ANAL.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON MAR 11 02:23:27 2016

* GLOBAL NET DEFINITIONS
.GLOBAL VCM_REF! VDD!
* FILE NAME: FINAL_PROJECT_FINAL_SCHEM_SOOCH_NCMF_ANAL_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_SCHEM_SOOCH_NCMF_ANAL.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 11 02:23:27 2016.

V1 NET8 0  1.25 AC 500E-3
V2 NET6 0  1.25 AC 500E-3 180.0
V0 VDD! 0  2.5
V3 VCM_REF! 0  1.25
I0 PB1 0  DC=4E-6  M=1.0
MN23 NET26 NET26 NB2 0  TSMC25DN  L=240E-9 W=960E-9 AD=576E-15 AS=576E-15
+PD=3.12E-6 PS=3.12E-6 M=1
MN22 NB1 NB1 0 0  TSMC25DN  L=240E-9 W=960E-9 AD=576E-15 AS=576E-15 PD=3.12E-6
+PS=3.12E-6 M=1
MN26 NB2 NET26 NB1 0  TSMC25DN  L=720E-9 W=960E-9 AD=576E-15 AS=576E-15
+PD=3.12E-6 PS=3.12E-6 M=1
MN40 NET43 NB2 NET32 0  TSMC25DN  L=240E-9 W=28.8E-6 AD=17.28E-12 AS=17.28E-12
+PD=58.8E-6 PS=58.8E-6 M=1
MN39 NET32 NB1 0 0  TSMC25DN  L=240E-9 W=28.8E-6 AD=17.28E-12 AS=17.28E-12
+PD=58.8E-6 PS=58.8E-6 M=1
MN34 B NET38 NET43 0  TSMC25DN  L=240E-9 W=14.4E-6 AD=8.64E-12 AS=8.64E-12
+PD=30E-6 PS=30E-6 M=1
MN33 NET66 NET86 NET43 0  TSMC25DN  L=240E-9 W=14.4E-6 AD=8.64E-12 AS=8.64E-12
+PD=30E-6 PS=30E-6 M=1
MP17 PB1 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=2.88E-6 AD=1.728E-12 AS=1.728E-12
+PD=6.96E-6 PS=6.96E-6 M=1
MP18 NET26 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=2.88E-6 AD=1.728E-12
+AS=1.728E-12 PD=6.96E-6 PS=6.96E-6 M=1
MP30 NET83 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP33 0 VCM_REF! NET38 VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP32 NET38 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP37 NET66 NET66 VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP36 B B VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12 AS=25.92E-12
+PD=87.6E-6 PS=87.6E-6 M=1
MP35 NET79 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12
+AS=25.92E-12 PD=87.6E-6 PS=87.6E-6 M=1
MP34 0 NET6 NET79 VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12 AS=25.92E-12
+PD=87.6E-6 PS=87.6E-6 M=1
MP31 0 NET8 NET83 VDD!  TSMC25DP  L=240E-9 W=43.2E-6 AD=25.92E-12 AS=25.92E-12
+PD=87.6E-6 PS=87.6E-6 M=1
R1 NET86 NET79  25E3 M=1.0
R0 NET83 NET86  25E3 M=1.0

.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dN" NMOS
.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dP" PMOS

* INCLUDE FILES

* END OF NETLIST
.TEMP    25.0000
.OP
.save
.OPTION  POST
.ac dec 100 1e3 1e9
.meas ac frequnityn when VDB(VOUTN)=0
.meas ac frequnityp when VDB(VOUTP)=0
*Scan out to unity gain frequency to find open loop gain
.meas ac Pgain max vdb(VOUTP) FROM=10 TO=frequnityp
.meas ac Ngain max vdb(VOUTN) FROM=10 TO=frequnityn
.meas ac min_phasen MIN vp(VOUTN) FROM=1 TO=frequnityn
.meas ac min_phasep MIN vp(VOUTP) FROM=1 TO=frequnityp
.meas ac PM = param('180+min_phasep')

.meas ac freq3db2 when VDB(B)=-3
.meas ac frequnity2 when VDB(B)=0
*Scan out to unity gain frequency to find open loop gain
.meas ac gain2 max vdb(B) FROM=10 TO=frequnity2
.meas ac min_phase2 MIN vp(B) FROM=1 TO=frequnity2
.meas ac PM2 = param('min_phase2')

.END
