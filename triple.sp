* # FILE NAME: /NFS/STAK/STUDENTS/L/LOVETR/CADENCE/SIMULATION/
* FINAL_SCHEM_TRIPLE/HSPICES/SCHEMATIC/NETLIST/FINAL_SCHEM_TRIPLE.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON MAR 11 01:36:46 2016

* GLOBAL NET DEFINITIONS
.GLOBAL VCM_REF! VDD!
* FILE NAME: FINAL_PROJECT_FINAL_SCHEM_TRIPLE_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_SCHEM_TRIPLE.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 11 01:36:46 2016.

C1 VOUTN 0  3E-12 M=1.0
C0 VOUTP 0  3E-12 M=1.0
I0 PB1 0  DC=225E-6  M=1.0
V2 VINN 0  1.25 AC 500E-3 180.0
V3 VCM_REF! 0  1.25
V0 VDD! 0  2.5
V1 VINP 0  1.25 AC 500E-3
MP27 VOUTP PB3 NET0194 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-18
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP28 VOUTN PB3 NET0190 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-18
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP24 PB3 NET0167 PB2 VDD!  TSMC25DP  L=720E-9 W=71.64E-6 AD=42.984E-12
+AS=42.984E-12 PD=144.48E-6 PS=144.48E-6 M=1
MP16 B B VDD! VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12 AS=86.04E-12
+PD=288E-6 PS=288E-6 M=1
MP15 NET0299 NET0299 VDD! VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-12
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP26 NET0167 NET0167 PB3 VDD!  TSMC25DP  L=240E-9 W=71.64E-6 AD=42.984E-12
+AS=42.984E-12 PD=144.48E-6 PS=144.48E-6 M=1
MP22 PB1 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=71.64E-6 AD=42.984E-12
+AS=42.984E-12 PD=144.48E-6 PS=144.48E-6 M=1
MP18 NET0232 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=71.64E-6 AD=42.984E-12
+AS=42.984E-12 PD=144.48E-6 PS=144.48E-6 M=1
MP23 PB2 NET0167 PB1 VDD!  TSMC25DP  L=1.2E-6 W=71.64E-6 AD=42.984E-12
+AS=42.984E-12 PD=144.48E-6 PS=144.48E-6 M=1
MP17 PB1 PB1 VDD! VDD!  TSMC25DP  L=240E-9 W=71.64E-6 AD=42.984E-12
+AS=42.984E-12 PD=144.48E-6 PS=144.48E-6 M=1
MP5 NET0190 PB2 NET238 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-18
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP4 NET0194 PB2 NET234 VDD!  TSMC25DP  L=240E-9 W=143.4E-6 AD=86.04E-18
+AS=86.04E-12 PD=288E-6 PS=288E-6 M=1
MP3 NET238 B VDD! VDD!  TSMC25DP  L=240E-9 W=286.8E-6 AD=172.08E-12
+AS=172.08E-12 PD=574.8E-6 PS=574.8E-6 M=1
MP2 NET234 B VDD! VDD!  TSMC25DP  L=240E-9 W=286.8E-6 AD=172.08E-12
+AS=172.08E-12 PD=574.8E-6 PS=574.8E-6 M=1
MN33 NET0250 NET0250 0 0  TSMC25DN  L=660E-9 W=75E-6 AD=45E-12 AS=45E-12
+PD=151.2E-6 PS=151.2E-6 M=1
MN29 NET0167 NB1 0 0  TSMC25DN  L=240E-9 W=25.2E-6 AD=15.12E-12 AS=15.12E-12
+PD=51.6E-6 PS=51.6E-6 M=1
MN26 NB2 NET0232 NB1 0  TSMC25DN  L=1.2E-6 W=25.2E-6 AD=15.12E-12 AS=15.12E-12
+PD=51.6E-6 PS=51.6E-6 M=1
MN22 NB1 NB1 0 0  TSMC25DN  L=240E-9 W=25.2E-6 AD=15.12E-12 AS=15.12E-12
+PD=51.6E-6 PS=51.6E-6 M=1
MN34 NET0243 NET0243 0 0  TSMC25DN  L=660E-9 W=75E-6 AD=45E-12 AS=45E-12
+PD=151.2E-6 PS=151.2E-6 M=1
MN19 B VCM_REF! NET0250 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1
MN24 NET0232 NET0232 NB3 0  TSMC25DN  L=240E-9 W=25.2E-6 AD=15.12E-12
+AS=15.12E-12 PD=51.6E-6 PS=51.6E-6 M=1
MN23 NB3 NET0232 NB2 0  TSMC25DN  L=720E-9 W=25.2E-6 AD=15.12E-12 AS=15.12E-12
+PD=51.6E-6 PS=51.6E-6 M=1
MN36 VOUTP NB3 NET0255 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1
MN21 NET0299 VOUTN NET0243 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1
MN15 NET241 NB2 NET0173 0  TSMC25DN  L=240E-9 W=99.96E-6 AD=59.976E-12
+AS=59.976E-12 PD=201.12E-6 PS=201.12E-6 M=1
MN18 NET0299 VOUTP NET0250 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1
MN20 B VCM_REF! NET0243 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1
MN37 VOUTN NB3 NET0251 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1
MN6 NET0251 NB2 NET212 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1
MN5 NET0255 NB2 NET226 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1
MN4 NET212 NB1 0 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12 AS=30.024E-12
+PD=101.28E-6 PS=101.28E-6 M=1
MN3 NET226 NB1 0 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12 AS=30.024E-12
+PD=101.28E-6 PS=101.28E-6 M=1
MN2 NET0173 NB1 0 0  TSMC25DN  L=240E-9 W=99.96E-6 AD=59.976E-12 AS=59.976E-12
+PD=201.12E-6 PS=201.12E-6 M=1
MN1 NET234 VINN NET241 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1
MN0 NET238 VINP NET241 0  TSMC25DN  L=240E-9 W=50.04E-6 AD=30.024E-12
+AS=30.024E-12 PD=101.28E-6 PS=101.28E-6 M=1

.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dN" NMOS
.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dP" PMOS

* INCLUDE FILES

* END OF NETLIST
.TEMP    25.0000
.OP
.save
.OPTION  POST
.END
